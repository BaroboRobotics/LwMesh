# IAR project Rcb128rfa1_ATmega128rfa1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128rfa1 ATmega128RFA1
  ICCAVR.CCDefines: PHY_ATMEGA128RFA1; HAL_ATMEGA128RFA1; PLATFORM_RCB128RFA1; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atmega128rfa1/inc; ../../../phy/atmega128rfa1/inc; ../../../nwk/inc; ../../../sys/inc; ../../../service/inc; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: otaInterface.c leds.h config.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/atmega128rfa1/src
    ../../../phy/atmega128rfa1/src/: phy.c
  group stack/phy/atmega128rfa1/inc
    ../../../phy/atmega128rfa1/inc/: phy.h atmega128rfa1.h
  group stack/hal/atmega128rfa1/src
    ../../../hal/atmega128rfa1/src/: halSleep.c halTimer.c halUart.c hal.c
  group stack/hal/atmega128rfa1/inc
    ../../../hal/atmega128rfa1/inc/: hal.h halTimer.h halSleep.h halGpio.h halUart.h
  group stack/service/src
    ../../../service/src/: otaClient.c
  group stack/service/inc
    ../../../service/inc/: otaCommon.h otaClient.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkSecurity.c nwkFrame.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkPrivate.h nwk.h
