# IAR project ZigBit_ATmega1281_Rf230.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1281 ATmega1281
  ICCAVR.CCDefines: PHY_AT86RF230; HAL_ATMEGA1281; PLATFORM_ZIGBIT; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atmega1281/inc; ../../../phy/at86rf230/inc; ../../../nwk/inc; ../../../sys/inc; ../../../service/inc; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: otaInterface.c leds.h config.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/at86rf230/src
    ../../../phy/at86rf230/src/: phy.c
  group stack/phy/at86rf230/inc
    ../../../phy/at86rf230/inc/: phy.h at86rf230.h
  group stack/hal/atmega1281/src
    ../../../hal/atmega1281/src/: halPhy.c halTimer.c halUart.c hal.c halSleep.c
  group stack/hal/atmega1281/inc
    ../../../hal/atmega1281/inc/: halGpio.h halPhy.h halTimer.h hal.h halUart.h halSleep.h
  group stack/service/src
    ../../../service/src/: otaClient.c
  group stack/service/inc
    ../../../service/inc/: otaCommon.h otaClient.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkSecurity.c nwkFrame.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkPrivate.h nwk.h
