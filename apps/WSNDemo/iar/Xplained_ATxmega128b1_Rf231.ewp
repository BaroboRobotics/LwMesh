# IAR project Xplained_ATxmega128b1_Rf231.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128b1
  ICCAVR.CCDefines: PHY_AT86RF231; HAL_ATXMEGA128B1; PLATFORM_XPLAINED; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atxmega128b1/inc; ../../../phy/at86rf231/inc; ../../../nwk/inc; ../../../sys/inc; ../../../service/inc; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: otaInterface.c leds.h config.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/at86rf231/src
    ../../../phy/at86rf231/src/: phy.c
  group stack/phy/at86rf231/inc
    ../../../phy/at86rf231/inc/: phy.h at86rf231.h
  group stack/hal/atxmega128b1/src
    ../../../hal/atxmega128b1/src/: halTimer.c halSleep.c hal.c halUart.c halPhy.c
  group stack/hal/atxmega128b1/inc
    ../../../hal/atxmega128b1/inc/: halSleep.h hal.h halPhy.h halUart.h halGpio.h halTimer.h
  group stack/service/src
    ../../../service/src/: otaClient.c
  group stack/service/inc
    ../../../service/inc/: otaCommon.h otaClient.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkSecurity.c nwkFrame.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkPrivate.h nwk.h
